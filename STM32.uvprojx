# Keil uVision project STM32.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\CMSIS;.\FWlib\inc;.\USER;.\FWlib\src;.\USER\GPIO_Config;.\USER\DELAY;.\USER\EXTI_Config;.\USER\NVIC_Config;.\USER\sys;.\USER\EDP;.\USER\esp8266;.\USER\onenet;.\USER\usart;.\USER\MALLOC;.\USER\esp8266_send;.\USER\dht11;.\USER\ADC;.\USER\mq-2;.\USER\TIMER;.\USER\csb;.\USER\HMI;.\USER\MPU6050;.\USER\Timer1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTCODE
    ./CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group USER
    ./USER/: stm32f10x_it.c main.c interface.c
    ./USER/DELAY/: delay.c
    ./USER/usart/: usart.c
    ./USER/dht11/: dht11.c
    ./USER/TIMER/: timer.c
    ./USER/HMI/: hmi.c
  group FWlib
    ./FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group onenet
    ./USER/esp8266/: esp8266.c
    ./USER/EDP/: EdpKit.c
    ./USER/onenet/: onenet.c
    ./USER/esp8266_send/: esp8266_send.c
